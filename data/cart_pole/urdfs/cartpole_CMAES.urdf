Commit message: Starting code clean-up: removing double pendulum

File: data/cart_pole/urdfs/cartpole_CMAES.urdf (robot description, URDF)
Before this commit: robot UndampedCartPole, 2 links, 2 joints
Links:
- link pendulum: mass 0.129 -> 0.227
